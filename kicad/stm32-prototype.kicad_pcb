# Repository bradford-hamilton/stm32-prototype

File README.md:

###### stm32-prototype following Phil's Lab course: https://www.youtube.com/watch?v=aVUqaB0IMh4

---

###### TODO:
###### - add parts to BOM
###### - order boards

## KiCad design kicad/stm32-prototype.kicad_pcb

Parts:
C1, C2: 22u
C3, C11: 10u
C4, C5, C6, C7: 100n
C8: 10n
C9, C10: 1u
C12, C13: 10p
D1: RED
FB1: 120R
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: USB_B_Micro
J2, J3, J4: Conn_01x04_Pin
R1, R3, R4, R5: 1k5
R2: 10k
SW1: SW_SPDT; SW_SPDT_PCM12
U1: AMS1117-3.3; SOT-223-3_TabPin2
U2: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
Y1: 16MHz

Connections:
+3.3V: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C10.1, D1.2 (A), FB1.1, J2.1, J3.1, J4.1, R3.1, R4.1, R5.1, SW1.3 (C), U1.2 (VO), U2.1 (VBAT), U2.24 (VDD), U2.36 (VDD), U2.48 (VDD)
+3.3VA: C8.1, C9.1, FB1.2, U2.9 (VDDA)
/BOOT0: R2.2, U2.44 (BOOT0)
/HSE_IN: C12.1, U2.5 (PD0), Y1.1
/HSE_OUT: C13.1, U2.6 (PD1), Y1.3
/I2C2_SCL: J4.2, R4.2, U2.21 (PB10)
/I2C2_SDA: J4.3, R5.2, U2.22 (PB11)
/NRST: C11.1, U2.7 (NRST)
/PWR_LED_K: D1.1 (K), R1.1
/SWCLK: J3.3, U2.37 (PA14)
/SWDIO: J3.2, U2.34 (PA13)
/SW_BOOT0: R2.1, SW1.2 (B)
/USART1_RX: J2.3, U2.43 (PB7)
/USART1_TX: J2.2, U2.42 (PB6)
/USB_D+: J1.3 (D+), R3.2, U2.33 (PA12)
/USB_D-: J1.2 (D-), U2.32 (PA11)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, J1.5 (GND), J2.4, J3.4, J4.4, R1.2, SW1.1 (A), U1.1 (GND), U2.8 (VSSA), U2.23 (VSS), U2.35 (VSS), U2.47 (VSS), Y1.2, Y1.4
VBUS: C1.1, J1.1 (VBUS), U1.3 (VI)

Notes on the sheet:
CL=2*(CLO-Cs)=2*(10-5)pF=10pF
Microcontroller & USB
VDDA filtering
USB app note AN4879
Mounting Holes
VBUS from USB connector (nom. +5V) Min. 22uF inp./outp. caps
Power Supply
STM32 Prototype
1x 100nF per VDD pin

Board: 2 copper layers, 45.0 x 34.0 mm, 32 parts (0 on the bottom side), 18 nets.

## Commit log

2023-05-28 kicad files
2023-05-28 manufacturing files
2023-05-28 update readme with TODOs
2023-05-28 add schematic and pcb images
2023-05-28 remove markers from pcb screenshot
2023-05-28 rename images
